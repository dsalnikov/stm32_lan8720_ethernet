<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f4xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS</name>
    <group>
      <name>MemMang</name>
      <file>
        <name>$PROJ_DIR$\FreeRTOS\portable\MemMang\heap_4.c</name>
      </file>
    </group>
    <group>
      <name>portable</name>
      <file>
        <name>$PROJ_DIR$\FreeRTOS\portable\IAR\ARM_CM4F\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FreeRTOS\portable\IAR\ARM_CM4F\portasm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FreeRTOS\portable\IAR\ARM_CM4F\portmacro.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FreeRTOS\timers.c</name>
    </file>
  </group>
  <group>
    <name>lwip</name>
    <group>
      <name>api</name>
      <file>
        <name>$PROJ_DIR$\lwip\src\api\api_lib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\lwip\src\api\api_msg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\lwip\src\api\err.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\lwip\src\api\netbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\lwip\src\api\netdb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\lwip\src\api\netifapi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\lwip\src\api\sockets.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\lwip\src\api\tcpip.c</name>
      </file>
    </group>
    <group>
      <name>core</name>
      <group>
        <name>ipv4</name>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\ipv4\autoip.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\def.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\dhcp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\dns.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\ipv4\icmp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\ipv4\igmp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\ipv4\inet.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\ipv4\inet_chksum.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\ipv4\ip.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\ipv4\ip_addr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\ipv4\ip_frag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\memp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\netif.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\pbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\raw.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\stats.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\tcp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\tcp_in.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\tcp_out.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\timers.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lwip\src\core\udp.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>netif</name>
      <file>
        <name>$PROJ_DIR$\lwip\src\netif\etharp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\lwip\src\netif\slipif.c</name>
      </file>
    </group>
    <group>
      <name>port</name>
      <file>
        <name>$PROJ_DIR$\lwip\port\ethernetif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\lwip\port\sys_arch.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32F4-Discovery</name>
    <file>
      <name>$PROJ_DIR$\STM32F4-Discovery\stm32f4_discovery.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4-Discovery\stm32f4_discovery.h</name>
    </file>
  </group>
  <group>
    <name>STM32F4x7_ETH_Driver</name>
    <file>
      <name>$PROJ_DIR$\STM32F4x7_ETH_Driver\src\stm32f4x7_eth.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm32f4x7_eth_bsp.c</name>
    </file>
  </group>
  <group>
    <name>STM32F4xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\http_server.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lwipopts.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm32f4xx_it.c</name>
    </file>
  </group>
</project>


